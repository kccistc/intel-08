
# Make systemd build networkd/resolved subpackages
PACKAGECONFIG:append = " networkd resolved"
